# Keil uVision project wtrl031.1.uvprojx, settings and files
target wtrl031.1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L031K6Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: wtrl031.1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L031xx,DBG_STREAM,UNDER_DEV
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;../Inc/apps;../Inc/lcd1602;../Inc/apps/fsm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32l031xx.s
  group Application/User
    ../Src/: main.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Src/apps
    ../Src/apps/: appfwk.c appwatering.c eventq.c globals.c settings.c
  group Src/lcd1602
    ../Src/lcd1602/: lcd.c
  group Src/apps/fsm
    ../Src/apps/fsm/: fsmappl.c fsmbasic.c fsmedint.c fsmsets0.c fsmwatch.c fsmwatering.c
software components: CMSIS:CORE 4.3.0
